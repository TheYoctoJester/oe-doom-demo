BUILD_LDFLAGS += "-pthread"

BBCLASSEXTEND += "native"